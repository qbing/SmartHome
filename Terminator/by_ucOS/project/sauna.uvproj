# Keil uVision project sauna.uvproj, settings and files
target sauna (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sauna +hex
  c flags: Optim=1
  c define: QB_UCOSII STM32F10X_LD
  c include: ..\..\by_noOS\Src\framework;..\..\by_noOS\Src\driver;..\..\by_noOS\Src\util;..\Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group START
    ../startup/: startup_stm32f10x_md.s
  group init
    ../init/: main.c stm32f10x_it.c system_stm32f10x.c Delay.c CONFIG.c
  group FWlib
    ../FWlib/SRC/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group Driver
    ../Driver/: DS1820.c DS1820.h relay.c relay.h tty.c usart.c
  group UCOS_CORE
    ../kernel/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS_CONFIG
    ../kernel/CONFIG/: includes.h os_cfg.h
  group UCOS_PORT
    ../kernel/CPU/: os_cpu_c.c os_dbg.c os_dbg_r.c os_cpu_a.asm
  group APP
    ../APP/: task.c task.h
    ../../../: SHP.c SHP.h SHP_example.c SHP_example.h
